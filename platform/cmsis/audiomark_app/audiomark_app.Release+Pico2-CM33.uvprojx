# Keil uVision project audiomark_app.Release+Pico2-CM33.uvprojx, settings and files
target Release+Pico2-CM33 (6220000::V6.22::ARMCLANG)
  device: RP2350:Core0 RPi
  pack: Keil.RP2350_DFP.9.9.9
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x20040000,0x00040000) IROM(0x10000000,0x00200000) XRAM(0x20080000,0x00001000) XRAM2(0x20081000,0x00001000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: audiomark_app.axf
  c flags: Optim=6 OneElfS=1 v6Lang=6 v6Lto=1
  c define: OS_SUPPORT_CUSTOM GENERIC_ARCH
  c misc: -ffast-math -Wno-macro-redefined -Wno-pragma-pack -Wno-parentheses-equality -Wno-license-management -ffast-math -Wno-macro-redefined -Wno-pragma-pack -Wno-parentheses-equality -Wno-license-management
  c include: ../../../lib/speexdsp/include;../../../lib/speexdsp/libspeexdsp;../../../ports/arm/;../../../src;../../../lib/speexdsp/include/speex;../../../lib/speexdsp
  asm define: OS_SUPPORT_CUSTOM GENERIC_ARCH
  asm include: as above
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT6: RAM 0x20080000 size 0x1000
  memory RVCT7: RAM 0x20081000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x40000
  scatter file: .\RTE\Device\RP2350_Core0\rp2350.sct
  link misc: --entry=Reset_Handler --info summarysizes --diag_suppress=L6314W
  group App
    ../../../src/: ee_audiomark.c
    ../../../: main.c
    ../: platform_init.c
    ../missing_from_packs/: arm_s8_to_s16_unordered_with_offset.c
  group AudioMarkCore
    ../../../src/: ee_abf_f32.c ee_abf_f32_tables.c ee_aec_f32.c ee_anr_f32.c ee_kws.c ee_mfcc_f32.c ee_mfcc_f32_tables.c ee_nn_tables.c
    ../../../ports/arm/: th_api.c
  group Printf retarget
    ../: stdout_USART.c
  group Libspeex
    ../../../lib/speexdsp/libspeexdsp/: buffer.c fftwrap.c filterbank.c jitter.c kiss_fft.c kiss_fftr.c mdf.c preprocess.c resample.c scal.c smallft.c
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Event Recorder 1.1.0, CMSIS-View:Event Recorder 1.6.0, CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2, CMSIS:NN Lib 6.0.0, Utilities:perf_counter:Core 2.3.3, Device:Pico2 Board 1.5.1, Device:Startup 1.0.1
